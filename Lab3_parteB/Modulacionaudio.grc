options:
  parameters:
    author: J1E_G4
    generate_options: qt_gui
    id: moduladoramplitudMJ
    output_language: python
    title: Modulador_AM_GNURADIO
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.25'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.01'
    stop: '5'
    value: '0.25'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia TX
    start: '0'
    step: '1'
    stop: '31'
    value: '0'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    start: '0'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente de sensibilidad AM
    start: '-4'
    step: '0.01'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: frecuencia de muestreo
    start: '1'
    step: '1'
    stop: '300000'
    value: '200000'
  states: {}
- name: Audio
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Documentos/lab_comu_J1E_G4/lab1_parteB/Audio_de_prueba.wav
    repeat: 'True'
  states: {}
- name: ModuladorAM_J1E_0
  id: ModuladorAM_J1E
  parameters:
    Ac: Ac
    ka: ka
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: practica3_0
  id: practica3
  parameters:
    l_vector: '1024'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Envolventecompleja"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"envolvente compleja"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Audio, '0', rational_resampler_xxx_0, '0']
- [ModuladorAM_J1E_0, '0', blocks_complex_to_real_0, '0']
- [ModuladorAM_J1E_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuladorAM_J1E_0, '0', qtgui_time_sink_x_0, '0']
- [ModuladorAM_J1E_0, '0', uhd_usrp_sink_0, '0']
- [blocks_complex_to_real_0, '0', practica3_0, '0']
- [rational_resampler_xxx_0, '0', ModuladorAM_J1E_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
