options:
  parameters:
    author: J1E_G4
    generate_options: qt_gui
    id: moduladoramplitudMJ
    output_language: python
    title: Modulador_AM_GNURADIO
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: Cambio de banda
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    label: habilita portadora
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    start: '300'
    step: '100'
    stop: samp_rate/4
    value: '1000'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: samp_rate
    start: '0'
    step: '1'
    stop: '300000'
    value: '200000'
  states: {}
- name: Envolvente_compleja_0
  id: Envolvente_compleja
  parameters:
    Ac: Ac
    B: B
    K: K
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Documentos/lab_comu_J1E_G4/lab1_parteB/Audio_de_prueba.wav
    repeat: 'True'
  states: {}
- name: practica3_0
  id: practica3
  parameters:
    l_vector: '1024'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Envolventecompleja"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"envolvente compleja"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: samp_rate
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Envolvente_compleja_0, '0', qtgui_freq_sink_x_0, '0']
- [Envolvente_compleja_0, '0', qtgui_time_sink_x_0, '0']
- [Envolvente_compleja_0, '0', uhd_usrp_sink_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', Envolvente_compleja_0, '0']
- [rational_resampler_xxx_0, '0', practica3_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
