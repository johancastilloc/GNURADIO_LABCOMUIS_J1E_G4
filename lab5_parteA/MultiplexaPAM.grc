options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: MultiplexPAM
    output_language: python
    title: MultiplexaPAM
  states: {}

blocks:
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: Ancho pulso
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: D1
  id: variable_qtgui_range
  parameters:
    label: Retardo 1
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: D2
  id: variable_qtgui_range
  parameters:
    label: Retardo 2
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: D3
  id: variable_qtgui_range
  parameters:
    label: Retardo 3
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: D4
  id: variable_qtgui_range
  parameters:
    label: Retardo 4
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia mensaje
    start: '0'
    step: '10'
    stop: '10000'
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Pulsos
    start: '0'
    step: '1'
    stop: '10000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: ModulacionPAM_1
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_1_0
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_1_1
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_1_2
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: ModulacionPAM_1_2_0
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: D1
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: D2
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: D3
    type: float
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: D4
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Documentos/lab_comu_J1E_G4/lab1_parteB/Audio_de_prueba.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '1000'
    fftsize: '8192'
    nconnections: '6'
    type: float
    wintype: window.WIN_BLACKMAN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '6'
    size: 1024*4
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '100000'
    interp: '200000'
    type: fcc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: samp_rate*2
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 50e6
    gain0: '0'
    otw: sc16
    samp_rate: samp_rate*2
    sync: none
    type: fc32
  states: {}

connections:
- [ModulacionPAM_1, '0', blocks_add_xx_0, '0']
- [ModulacionPAM_1, '0', qtgui_freq_sink_x_0, '0']
- [ModulacionPAM_1, '0', qtgui_time_sink_x_0, '0']
- [ModulacionPAM_1_0, '0', blocks_delay_0, '0']
- [ModulacionPAM_1_1, '0', blocks_delay_0_0, '0']
- [ModulacionPAM_1_2, '0', blocks_delay_0_1, '0']
- [ModulacionPAM_1_2_0, '0', blocks_delay_0_1_0, '0']
- [analog_sig_source_x_0, '0', ModulacionPAM_1, '0']
- [analog_sig_source_x_0_0, '0', ModulacionPAM_1_0, '0']
- [analog_sig_source_x_0_0_0, '0', ModulacionPAM_1_1, '0']
- [analog_sig_source_x_0_0_0_0, '0', ModulacionPAM_1_2, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '4']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_add_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '2']
- [blocks_delay_0_0, '0', qtgui_freq_sink_x_0, '2']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0_1, '0', blocks_add_xx_0, '3']
- [blocks_delay_0_1, '0', qtgui_freq_sink_x_0, '3']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_0_1_0, '0', blocks_add_xx_0, '4']
- [blocks_delay_0_1_0, '0', qtgui_freq_sink_x_0, '5']
- [blocks_delay_0_1_0, '0', qtgui_time_sink_x_0, '5']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_1, '0', ModulacionPAM_1_2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
